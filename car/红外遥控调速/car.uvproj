# Keil uVision project car.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: car.c key.c delay.c smg.c time0.c Timer0.h Int0.c Int0.h IR.c IR.h Timer0.c
