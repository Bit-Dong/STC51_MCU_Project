# Keil uVision project T.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: T +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: T.c Delay.c Delay.h DS18B20.c DS18B20.h LCD1602.c LCD1602.h OneWire.c OneWire.h
